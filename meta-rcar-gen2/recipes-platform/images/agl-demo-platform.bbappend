# for Renesas R-Car2 M2 Porter
IMAGE_INSTALL_append_porter = " \
    gles-kernel-module \
    libegl \
    libgbm-dev \
    "
